# Keil uVision project GD32F303VCT6.uvprojx, settings and files
target APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./Firmware/bootloader.bin ./Objects/bootloader.axf
  AfterMake: C:\Program Files\Git\usr\bin\mv.exe .\Objects\bootloader.hex .\Firmware\
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,__TARGET_FPU_VFP
  c include: ..\Robot-BootLoader;.\CMSIS;.\CMSIS\GD32F30x\Include;.\GD32F30x_standard_peripheral\Include;.\FreeRTOS-Kernel\include;.\FreeRTOS-Kernel\portable\RVDS\ARM_CM4F;.\FreeRTOS-Kernel;.\Hardware;.\vl6180x;.\CodeSamples\inc;.\Common_API;.\YModem
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group IAP
    ./: main.c iap_config.h iap.c
  group CMSIS
    ./: gd32f30x_it.c
    ./CMSIS/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ./GD32F30x_standard_peripheral/Source/: gd32f30x_bkp.c gd32f30x_ctc.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_rcu.c gd32f30x_sdio.c gd32f30x_usart.c
  group Startup
    ./CMSIS/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group Hardware
    ./Hardware/: usart.c
